# Keil uVision project amingkl.uvproj, settings and files
target amingkl (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: amingkl
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Users;..\Hardware\LED;..\Hardware\KEY;..\Hardware\DELAY;..\Hardware\LCD;..\Hardware\USART;..\Hardware\IIC;..\Hardware\TIM;..\Hardware\DS18B20;..\Hardware\PULSE;..\Hardware\ADC;..\Hardware\ADC_AnalogVoltage;..\Hardware\Digital;..\Hardware\PWMCAPUTER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ./: startup_stm32f10x_md.s
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group USER
    ../Users/: main.c stm32f10x_it.c stm32f10x_conf.h myconfig.h
  group HARDWARE
    ../Hardware/LED/: bsp_led.c
    ../Hardware/KEY/: bsp_key.c
    ../Hardware/DELAY/: delay.c
    ../Hardware/USART/: usart.c
    ../Hardware/IIC/: i2c.c
    ../Hardware/TIM/: tim.c
    ../Hardware/DS18B20/: bsp_ds18b20.c
    ../Hardware/ADC/: bsp_adc.c
    ../Hardware/ADC_AnalogVoltage/: bsp_AnalogVoltage.c
    ../Hardware/Digital/: bsp_digital.c
    ../Hardware/PWMCAPUTER/: bsp_caputer.c
  group DOC
    ../DOC/: Read me.txt bsp_xx.c bsp_xx.h
  group LCD
    ../Hardware/LCD/: lcd.c
