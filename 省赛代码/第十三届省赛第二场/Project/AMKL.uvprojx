# Keil uVision project AMKL.uvprojx, settings and files
target AMKL (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AMKL +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Users;..\Hardware\DELAY;..\Hardware\IIC;..\Hardware\KEY;..\Hardware\LCD;..\Hardware\LED;..\Hardware\PWM;..\Hardware\TIM;..\Hardware\USART
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/STARTUP/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../Hardware/DELAY/: delay.c
    ../Hardware/IIC/: i2c.c
    ../Hardware/KEY/: bsp_key.c
    ../Hardware/LED/: bsp_led.c
    ../Hardware/PWM/: pwm.c
    ../Hardware/TIM/: tim.c
    ../Hardware/USART/: usart.c
  group USER
    ../Users/: main.c myconfig.c myconfig.h stm32f10x_it.c stm32f10x_conf.h
  group LCD
    ../Hardware/LCD/: lcd.c lcd.h fonts.H
software components: CMSIS:CORE 5.4.0
