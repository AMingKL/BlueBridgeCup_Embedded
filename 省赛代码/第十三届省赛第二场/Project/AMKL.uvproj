# Keil uVision project AMKL.uvproj, settings and files
target AMKL (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: AMKL +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Users;..\Hardware\DELAY;..\Hardware\IIC;..\Hardware\KEY;..\Hardware\LCD;..\Hardware\LED;..\Hardware\PWM;..\Hardware\TIM;..\Hardware\USART
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/STARTUP/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../Hardware/DELAY/: delay.c
    ../Hardware/IIC/: i2c.c
    ../Hardware/KEY/: bsp_key.c
    ../Hardware/LED/: bsp_led.c
    ../Hardware/PWM/: pwm.c
    ../Hardware/TIM/: tim.c
    ../Hardware/USART/: usart.c
  group USER
    ../Users/: main.c myconfig.c myconfig.h stm32f10x_it.c stm32f10x_conf.h
  group LCD
    ../Hardware/LCD/: lcd.c lcd.h fonts.H
